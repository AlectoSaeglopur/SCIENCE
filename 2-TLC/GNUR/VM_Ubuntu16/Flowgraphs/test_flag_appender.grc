<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_flag_appender</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/vkn/Documents/GNUR/Flowgraphs/Logs/flag_appender.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>zVKN_flag_appender_c_mm</key>
<param><key>id</key><value>zVKN_flag_appender_c_mm_0</value></param>
<param><key>flag_pos</key><value>True</value></param>
<param><key>flag_val</key><value>0xD391</value></param>
</block>
<block>
<key>zVKN_flag_appender_p_mm</key>
<param><key>id</key><value>zVKN_flag_appender_p_mm_0</value></param>
<param><key>flag_pos</key><value>False</value></param>
<param><key>flag_val</key><value>(0xAB,0xCD,0xEF)</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>zVKN_flag_appender_c_mm_0</sink_block_id><source_key>pdus</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_flag_appender_c_mm_0</source_block_id><sink_block_id>zVKN_flag_appender_p_mm_0</sink_block_id><source_key>port_out</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>zVKN_flag_appender_p_mm_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>port_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>zVKN_flag_appender_p_mm_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>port_out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
