<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_protocol_header_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>zVKN_prot_header_tx_p_mm</key>
<param><key>id</key><value>zVKN_prot_header_tx_p_mm_0</value></param>
<param><key>LenSz</key><value>1</value></param>
<param><key>Order</key><value>2</value></param>
<param><key>PrbSz</key><value>6</value></param>
<param><key>SwVal</key><value>(0xD3,0x91)</value></param>
<param><key>Dummy</key><value>(0xFF,0xFF)</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>zVKN_prot_header_tx_p_mm_0</sink_block_id><source_key>pdus</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>zVKN_prot_header_tx_p_mm_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>port_out</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
