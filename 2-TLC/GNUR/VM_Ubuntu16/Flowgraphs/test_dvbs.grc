<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_dvbs</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AgcLev</value></param>
<param><key>comment</key><value>AGC output level
[V] (NB: see note!)</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ChDly</value></param>
<param><key>comment</key><value>Channel
delay [Sa]</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs</value></param>
<param><key>comment</key><value>Samp rate
[Sa/s]</value></param>
<param><key>value</key><value>osf*Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LenSz</value></param>
<param><key>comment</key><value>Length-field
size [B]</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>comment</key><value>PSK
order</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PhOfs</value></param>
<param><key>comment</key><value>PSK phase
offset [deg]</value></param>
<param><key>value</key><value>180.0/M</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>comment</key><value>Bit rate
[b/s]</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>comment</key><value>Symb rate
[Sy/s]</value></param>
<param><key>value</key><value>Rb/log2(M)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SwCorTol</value></param>
<param><key>comment</key><value>Sw Correlation
threshold [%]</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SyncWord</value></param>
<param><key>comment</key><value>SyncWord value</value></param>
<param><key>value</key><value>(0xD3,0x91,0xFF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>comment</key><value>RRC RO
factor</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osf</value></param>
<param><key>comment</key><value>OverSamp
Factor [Sa/Sy]</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>span</value></param>
<param><key>comment</key><value>RRC span
[Sy]</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>ChDly</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>comment</key><value>to remove RX
SRRC delay</value></param>
<param><key>num_items</key><value>span*osf/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>span*osf/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Fs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import log2, sqrt</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>The parameter "AgcLev" represents
the expected signal AVERAGE voltage
amplitude entering the PSK decoder.
- for M=2 set AgcLev=sqrt(2)
- for M=4 set AgcLev =1.
- for M=8 set AgcLev =1/sqrt(2).
- for M=16 set AgcLev= 0.5.
Experimentally these values allow to
match quite accurately the after-SRRC
and after-AGC waveforms in RX. Keep
in mind these factors are intended to
better follow the actual power of the
modulated signal (which is of course
unknown, but for sure larger than that
of a pure sinusoid).</value></param>
<param><key>note</key><value>AgcLev setting</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>The overll chain has been tested also by
inverting the SRRC and AGC blocks in RX.
In this case (i.e. AGC placed before SRRC)
the only parameter to update is AgcLev
(to be reduced at least by a factor of 2).</value></param>
<param><key>note</key><value>SRRC+AGC order</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>The chain has been succefully tested for
M up to 16. Experimentally the main
parameters affecting performance are :
- AgcLev (to be adjusted depending on M),
- AGC's window size (to be kept large),
- PKK Decoder's correlation-window step
  (to be kept low for better SW detection
  accuracy).</value></param>
<param><key>note</key><value>misc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>Fs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>enable "MaxHold"</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>TX</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>SPECTRUM</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-60</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>TX (I)</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>TX (Q)</value></param>
<param><key>marker2</key><value>8</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>CHAN (I)</value></param>
<param><key>marker3</key><value>0</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>label4</key><value>CHAN (Q)</value></param>
<param><key>marker4</key><value>8</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>SRRC (I)</value></param>
<param><key>marker5</key><value>0</value></param>
<param><key>color6</key><value>"cyan"</value></param>
<param><key>label6</key><value>SRRC (Q)</value></param>
<param><key>marker6</key><value>8</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>color7</key><value>"red"</value></param>
<param><key>label7</key><value>AGC (I)</value></param>
<param><key>marker7</key><value>0</value></param>
<param><key>color8</key><value>"red"</value></param>
<param><key>label8</key><value>AGC (Q)</value></param>
<param><key>marker8</key><value>8</value></param>
<param><key>style8</key><value>2</value></param>
<param><key>name</key><value>TIME</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_delay</key><value>2e-3</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>zVKN_awgn_p_cc</key>
<param><key>id</key><value>zVKN_awgn_p_cc_0</value></param>
<param><key>Dly</key><value>ChDly</value></param>
<param><key>Gain</key><value>-7</value></param>
<param><key>N0</key><value>-40</value></param>
</block>
<block>
<key>zVKN_check_rx_pkt_p_mx</key>
<param><key>id</key><value>zVKN_check_rx_pkt_p_mx_0</value></param>
</block>
<block>
<key>zVKN_prot_header_tx_p_mm</key>
<param><key>id</key><value>zVKN_prot_header_tx_p_mm_0</value></param>
<param><key>comment</key><value>NB: Preable, SW and length
sizes (converted in bits) shall
be divisible by log2(M)</value></param>
<param><key>LenSz</key><value>LenSz</value></param>
<param><key>Order</key><value>M</value></param>
<param><key>PrbSz</key><value>9</value></param>
<param><key>SwVal</key><value>SyncWord</value></param>
<param><key>Dummy</key><value>(0xFF,0xFF)</value></param>
</block>
<block>
<key>zVKN_psk_decoder</key>
<param><key>id</key><value>zVKN_psk_decoder_0</value></param>
<param><key>WinSp</key><value>1</value></param>
<param><key>LenSz</key><value>LenSz</value></param>
<param><key>PhOfs</key><value>PhOfs</value></param>
<param><key>Order</key><value>M</value></param>
<param><key>Rotat</key><value>True</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>osf</key><value>osf</value></param>
<param><key>SwCorTlr</key><value>SwCorTol</value></param>
<param><key>SwVal</key><value>SyncWord</value></param>
</block>
<block>
<key>zVKN_psk_mapper_p_mm</key>
<param><key>id</key><value>zVKN_psk_mapper_p_mm_0</value></param>
<param><key>Offset</key><value>PhOfs</value></param>
<param><key>Order</key><value>M</value></param>
<param><key>Rotation</key><value>True</value></param>
</block>
<block>
<key>zVKN_squelch_agc_p_cc</key>
<param><key>id</key><value>zVKN_squelch_agc_p_cc_0</value></param>
<param><key>AgcMode</key><value>False</value></param>
<param><key>AmpGain</key><value>0</value></param>
<param><key>AmpRef</key><value>0</value></param>
<param><key>OfsRef</key><value>0</value></param>
<param><key>OfsGain</key><value>0</value></param>
<param><key>VoutMax</key><value>AgcLev*1.5</value></param>
<param><key>PwrGain</key><value>0.75</value></param>
<param><key>PwrRef</key><value>(AgcLev**2)*(1+1j)/2</value></param>
<param><key>SqEnab</key><value>True</value></param>
<param><key>SqLev</key><value>1e-3</value></param>
<param><key>WinSz</key><value>16*osf</value></param>
</block>
<block>
<key>zVKN_srrc_filter_rx_c_cc</key>
<param><key>id</key><value>zVKN_srrc_filter_rx_c_cc_1</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>sps</key><value>osf</value></param>
</block>
<block>
<key>zVKN_srrc_filter_tx_c_cc</key>
<param><key>id</key><value>zVKN_srrc_filter_tx_c_cc_0</value></param>
<param><key>comment</key><value>NB: tag "packet_len" is
removed by this block</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>sps</key><value>osf</value></param>
</block>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>zVKN_srrc_filter_tx_c_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>zVKN_prot_header_tx_p_mm_0</sink_block_id><source_key>pdus</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>zVKN_awgn_p_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>zVKN_srrc_filter_rx_c_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_prot_header_tx_p_mm_0</source_block_id><sink_block_id>zVKN_psk_mapper_p_mm_0</sink_block_id><source_key>port_out</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>zVKN_psk_decoder_0</source_block_id><sink_block_id>zVKN_check_rx_pkt_p_mx_0</sink_block_id><source_key>port_out</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>zVKN_psk_mapper_p_mm_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>port_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zVKN_squelch_agc_p_cc_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_squelch_agc_p_cc_0</source_block_id><sink_block_id>zVKN_psk_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_rx_c_cc_1</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_rx_c_cc_1</source_block_id><sink_block_id>zVKN_squelch_agc_p_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
