<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_rx_configs</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AgcLev</value></param>
<param><key>comment</key><value>AGC output
level [V]</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs</value></param>
<param><key>comment</key><value>Samp rate
[Sa/s]</value></param>
<param><key>value</key><value>osf*Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>comment</key><value>PSK
order</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>comment</key><value>Bit rate
[b/s]</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>comment</key><value>Symb rate
[Sy/s]</value></param>
<param><key>value</key><value>Rb/log2(M)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>comment</key><value>SRRC
RO Fact</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osf</value></param>
<param><key>comment</key><value>OverSa
Factor
[Sa/Sy]</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>span</value></param>
<param><key>comment</key><value>SRRC
span
[Sy]</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>span*osf/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>span*osf/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0_0</value></param>
<param><key>num_items</key><value>span*osf/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Fs</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import log2, sqrt</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>The AGC+SRRC case provides
a faster convergence (since the
AGC keeps its compensating
factor up-to-date by directly
and continuouly sensing the
channel noise level), but less
accurate (since the AGC processes
more high frequency noise coming
from the channel itself).

Instead, in the SRRC+AGC case the
tracking is more accurate (since
the initial SRRC filter removes most
of the high frequency channel noise)
but slower (since now the AGC
experiences a more abrupt power
change at the beginning of packet
reception, causing its compensating
factor to overshoot).

Anyway, SRRC+AGC should be probably
preferred since its speed drawback can
be compensated by further increasing
the loop gain (since due to the initial
SRRC filtering in this configuration the
AGC is less sensible to channel noise).</value></param>
<param><key>note</key><value>EXPERIMENTAL RESULTS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>TX (I)</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>TX (Q)</value></param>
<param><key>marker2</key><value>8</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>CHAN (I)</value></param>
<param><key>marker3</key><value>0</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>label4</key><value>CHAN (Q)</value></param>
<param><key>marker4</key><value>8</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>SRRC (I)</value></param>
<param><key>marker5</key><value>0</value></param>
<param><key>color6</key><value>"cyan"</value></param>
<param><key>label6</key><value>SRRC (Q)</value></param>
<param><key>marker6</key><value>8</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>color7</key><value>"red"</value></param>
<param><key>label7</key><value>AGC (I)</value></param>
<param><key>marker7</key><value>0</value></param>
<param><key>color8</key><value>"red"</value></param>
<param><key>label8</key><value>AGC (Q)</value></param>
<param><key>marker8</key><value>8</value></param>
<param><key>style8</key><value>2</value></param>
<param><key>name</key><value>SRRC+AGC</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs</value></param>
<param><key>tr_delay</key><value>0.02</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>TX (I)</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>TX (Q)</value></param>
<param><key>marker2</key><value>8</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>CHAN (I)</value></param>
<param><key>marker3</key><value>0</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>label4</key><value>CHAN (Q)</value></param>
<param><key>marker4</key><value>8</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>AGC (I)</value></param>
<param><key>marker5</key><value>0</value></param>
<param><key>color6</key><value>"cyan"</value></param>
<param><key>label6</key><value>AGC (Q)</value></param>
<param><key>marker6</key><value>8</value></param>
<param><key>style6</key><value>2</value></param>
<param><key>color7</key><value>"red"</value></param>
<param><key>label7</key><value>SRRC (I)</value></param>
<param><key>marker7</key><value>0</value></param>
<param><key>color8</key><value>"red"</value></param>
<param><key>label8</key><value>SRRC (Q)</value></param>
<param><key>marker8</key><value>8</value></param>
<param><key>style8</key><value>2</value></param>
<param><key>name</key><value>AGC+SRRC</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Fs</value></param>
<param><key>tr_delay</key><value>0.02</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>zVKN_awgn_p_cc</key>
<param><key>id</key><value>zVKN_awgn_p_cc_0</value></param>
<param><key>Gain</key><value>-5</value></param>
<param><key>N0</key><value>-30</value></param>
</block>
<block>
<key>zVKN_psk_mapper_p_mm</key>
<param><key>id</key><value>zVKN_psk_mapper_p_mm_0</value></param>
<param><key>Offset</key><value>45</value></param>
<param><key>Order</key><value>M</value></param>
<param><key>Rotation</key><value>True</value></param>
</block>
<block>
<key>zVKN_squelch_agc_p_cc</key>
<param><key>id</key><value>zVKN_squelch_agc_p_cc_0_0</value></param>
<param><key>AgcMode</key><value>False</value></param>
<param><key>AmpGain</key><value>0</value></param>
<param><key>AmpRef</key><value>0</value></param>
<param><key>OfsRef</key><value>0</value></param>
<param><key>OfsGain</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>PwrGain</key><value>0.6</value></param>
<param><key>PwrRef</key><value>(AgcLev**2)*(1+1j)/2</value></param>
<param><key>SqEnab</key><value>True</value></param>
<param><key>SqLev</key><value>10e-3</value></param>
<param><key>WinSz</key><value>8*osf</value></param>
</block>
<block>
<key>zVKN_squelch_agc_p_cc</key>
<param><key>id</key><value>zVKN_squelch_agc_p_cc_0_0_0</value></param>
<param><key>AgcMode</key><value>False</value></param>
<param><key>AmpGain</key><value>0</value></param>
<param><key>AmpRef</key><value>0</value></param>
<param><key>comment</key><value>"PwrRef" is set lower here since
the following SRRC filter generates
a further amplification (the actual
factor depends on the SRRC taps
design)</value></param>
<param><key>OfsRef</key><value>0</value></param>
<param><key>OfsGain</key><value>0</value></param>
<param><key>PwrGain</key><value>0.6</value></param>
<param><key>PwrRef</key><value>(AgcLev**2)*(1+1j)/2*0.18</value></param>
<param><key>SqEnab</key><value>True</value></param>
<param><key>SqLev</key><value>10e-3</value></param>
<param><key>WinSz</key><value>8*osf</value></param>
</block>
<block>
<key>zVKN_srrc_filter_rx_c_cc</key>
<param><key>id</key><value>zVKN_srrc_filter_rx_c_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>sps</key><value>osf</value></param>
</block>
<block>
<key>zVKN_srrc_filter_rx_c_cc</key>
<param><key>id</key><value>zVKN_srrc_filter_rx_c_cc_1</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>sps</key><value>osf</value></param>
</block>
<block>
<key>zVKN_srrc_filter_tx_c_cc</key>
<param><key>id</key><value>zVKN_srrc_filter_tx_c_cc_0</value></param>
<param><key>comment</key><value>NB: Tag "packet_len" is
removed by this block</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>span</key><value>span</value></param>
<param><key>sps</key><value>osf</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>zVKN_psk_mapper_p_mm_0</sink_block_id><source_key>pdus</source_key><sink_key>port_in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>zVKN_srrc_filter_tx_c_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>zVKN_squelch_agc_p_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_awgn_p_cc_0</source_block_id><sink_block_id>zVKN_srrc_filter_rx_c_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_psk_mapper_p_mm_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>port_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zVKN_squelch_agc_p_cc_0_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_squelch_agc_p_cc_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>zVKN_squelch_agc_p_cc_0_0_0</source_block_id><sink_block_id>zVKN_srrc_filter_rx_c_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_rx_c_cc_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_rx_c_cc_0</source_block_id><sink_block_id>zVKN_squelch_agc_p_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_rx_c_cc_1</source_block_id><sink_block_id>blocks_skiphead_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zVKN_srrc_filter_tx_c_cc_0</source_block_id><sink_block_id>zVKN_awgn_p_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
